# Keil uVision project finalproject_moy.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: finalproject_moy
  c flags: Optim=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\Keil\LPC1700_DFP\2.0.0\Device\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./finalproject_moy Files/: AsciiLib.c AsciiLib.h Font_24x16.h GLCD.c GLCD.h startup_lpc17xx.s system_LPC17xx.c type.h uart.c uart.h project.c
